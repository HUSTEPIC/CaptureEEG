# Keil uVision project EEG_CH559.uvproj, settings and files
target CaptureEEG (MCS-51)
  device: 8051 (all Variants) Generic
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: EEG_CH559 +hex
  c flags: Optimize=8 SizeSpeed=1
  group CaptureEEG
    ./Src/: DEBUG.C USBCOM.C ADS1299.C MAIN.C
